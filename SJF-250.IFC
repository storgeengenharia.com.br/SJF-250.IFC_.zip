Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: SJF-250.IFC
Time: 2024-09-09T13:01:34
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Cone de Aspiração 250
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Corpo
In: Default Storey
Material: Aço galvanizado

# IfcBuildingElementProxy: Suporte Motor
In: Default Storey
Material: Aço galvanizado

# IfcBuildingElementProxy: Suporte para Fixação (2)
In: Default Storey
Material: Aço galvanizado

# IfcBuildingElementProxy: Tampa
In: Default Storey
Material: Aço galvanizado

# IfcBuildingElementProxy: Tampa Motor
In: Default Storey
Material: Aço galvanizado
